# Keil uVision project HighCurrency.uvprojx, settings and files
target HighCurrency (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IIC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\USMART;..\HARDWARE\MODBUS;..\HARDWARE\ITEMP;..\HARDWARE\SPI;..\HARDWARE\ads1110;..\HARDWARE\calculate;..\HARDWARE\TIMER;..\HARDWARE\get_data;..\HARDWARE\ltc6803-2;..\HARDWARE\DMA;..\HARDWARE\ntc;..\HARDWARE\WDG;..\HARDWARE\mcp3421;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\DAC;..\HARDWARE\TIMER;..\HARDWARE\mcp4726;..\HARDWARE\task
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c control.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/MODBUS/: MODBUS.C
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ntc/: ntc.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/mcp3421/: mcp3421.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/mcp4726/: mcp4726.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_dac.c
  group README
    ../: README.TXT
  group TASK
    ../HARDWARE/task/: task.c taskLed.c taskModbus.c
